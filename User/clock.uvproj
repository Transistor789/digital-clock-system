# Keil uVision project clock.uvproj, settings and files
target test (MCS-51)
  device: STC89C52RC STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(45000000) MODP2
  output: clock +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\Driver;..\System;..\User
  group User
    ./: main.c
  group Driver
    ../Driver/: seg.c key.c ds1302.c i2c.c onewire.c
  group System
    ../System/: timer.c delay.c
